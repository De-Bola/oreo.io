# Keil uVision project LightSensor.uvproj, settings and files
target LightSensorLab_part3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LightSensor
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup.s ADC.h ADC.c Main.c UART.c UART.h Init.c Init.h
